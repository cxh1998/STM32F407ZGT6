# Keil uVision project STM32F407ZGT6.uvprojx, settings and files
target STM32F407ZGT6 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: STM32F407ZGT6 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\core;..\Application;..\fwlib\inc;..\drivers
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ./: main.c function.c stm32f4xx_it.c system_stm32f4xx.c stm32f407zgt6.h
  group drivers
    ../drivers/: usart.c delay.c led.c key.c dma.c iic.c iwdg.c sys.c 24cxx.c wwdg.c spi.c
  group fwlib
    ../fwlib/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_iwdg.c stm32f4xx_wwdg.c stm32f4xx_dma.c
  group core
    ../core/: startup_stm32f40_41xxx.s
